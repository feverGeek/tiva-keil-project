# Keil uVision project project0.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: TM4C1236E6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IROM(0x00000000,0x020000) IRAM(0x20000000,0x008000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: project0 +hex
  c flags: Optim=1
  c define: rvmdk,PART_LM4F110B2QR,TARGET_IS_BLIZZARD_RA1
  c include: ..\USER;..\inc;..\Driverlib\inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group UserCode
    ../USER/: buck.c LCDDriver.c
  group StartCode
    ../StartCode/: startup_rvmdk.S
  group Driverlib
    F:/TivaWare_C_Series-2.1.4.178/TivaWare_C_Series-2.1.4.178/driverlib/rvmdk/: driverlib.lib
  group Header
    ../USER/: LCDDriver.h LCD_Matrix.h
